# Repository rodep-soft/RoDEP-Soccer-Robot-Circuit

File README.md:

# RoDEP Soccer Robot's Arduino Shield

## 基板CAD
Eagle

## 使用部品
- TB6612FNG x2  
デュアルモータードライバIC  
[購入先リンク](https://akizukidenshi.com/catalog/g/gI-11317/)
- PCF8574N x1  
Ｉ／Ｏエキスパンダー　ＰＣＦ８５７４Ｎ  
[購入先リンク](https://akizukidenshi.com/catalog/g/gI-13522/)
- MCP3008 x1  
１０ｂｉｔ　８ｃｈ　ＡＤコンバータ　ＭＣＰ３００８－Ｉ／Ｐ  
[購入先リンク](https://akizukidenshi.com/catalog/g/gI-09485/)
- ＩＣソケット（１６Ｐ）x1  
[購入先リンク](https://akizukidenshi.com/catalog/g/gP-00007/)
- ターミナルブロック　２Ｐ　緑　縦　小 x4  
[購入先リンク](https://akizukidenshi.com/catalog/g/gP-02333/)
- 表面実装用タクトスイッチ　ＴＳ－０６１０４ x1  
[購入先リンク](https://akizukidenshi.com/catalog/g/gP-15969/)
- 電解コンデンサー１０μＦ５０Ｖ８５℃　ルビコンＰＫ x2  
[購入先リンク](https://akizukidenshi.com/catalog/g/gP-03116/)
- チップ積層セラミックコンデンサー　０.１μＦ５０Ｖ　Ｆ　１６０８　（４０個入）x5  
[購入先リンク](https://akizukidenshi.com/catalog/g/gP-13374/)
- XHコネクタ3ピン　ポスト x16  
[秋月互換品](https://akizukidenshi.com/catalog/g/gC-17151/)  
[JST純正](https://order.jst-mfg.com/InternetShop/app/index?back=2&product=67526000&jgcd=0&view=ProductDetail)
- XHコネクタ4ピン　ポスト x1
[秋月互換品](https://akizukidenshi.com/catalog/g/gC-17152/)
- 0603サイズのチップ型抵抗10kΩ

## EAGLE design foArduinoMega.brd

Parts:
B1: ARDUINO_MEGA_R3FULL; ARDUINO_MEGA_NO_SILK
BALL1, BALL2, BALL3, BALL4: B3B-XH-A
CN9: B4B-XH-A
LINE1, LINE2, LINE3, LINE4: B3B-XH-A
PING1, PING2, PING3, PING4: B3B-XH-A

Connections:
+5V: B1.5V, B1.5V@1 (5V), B1.5V@2 (5V), BALL1.2, BALL2.2, BALL3.2, BALL4.2, CN9.4, LINE1.2, LINE2.2, LINE3.2, LINE4.2, PING1.2, PING2.2, PING3.2, PING4.2
GND: B1.GND, B1.GND@3 (GND), B1.GND@4 (GND), BALL1.3, BALL2.3, BALL3.3, BALL4.3, CN9.1, LINE1.3, LINE2.3, LINE3.3, LINE4.3, PING1.3, PING2.3, PING3.3, PING4.3
unnamed: B1.A11, BALL4.1
unnamed: B1.A10, BALL3.1
unnamed: B1.A9, BALL2.1
unnamed: B1.A8, BALL1.1
unnamed: B1.A15, LINE4.1
unnamed: B1.A14, LINE3.1
unnamed: B1.A13, LINE2.1
unnamed: B1.A12, LINE1.1
unnamed: B1.21 (21(SCL)), CN9.3
unnamed: B1.20 (20(SDA)), CN9.2
unnamed: B1.17 (17(RX2)), PING2.1
unnamed: B1.16 (16(TX2)), PING1.1
unnamed: B1.19 (19(RX1)), PING4.1
unnamed: B1.18 (18(TX1)), PING3.1

Notes on the sheet:
ボールセンサ
ラインセンサ
超音波センサ
方位センサ

Board: 2 copper layers, 47.0 x 72.0 mm, 14 parts (0 on the bottom side), 16 nets.

## EAGLE design Arduino-Shield.brd

Parts:
ALT1, ALT2, ALT3, ALT4: B3B-XH-A
BALL1, BALL2, BALL3, BALL4: B3B-XH-A
C1, C2: 10uF; E2-5
C3, C4, C5, C7, C8: 0.1uF; C1608
I2C: B4B-XH-A
LINE1, LINE2, LINE3, LINE4: B3B-XH-A
M1, M2, M3, M4: AK500/2-H
MCP3008: MCP3008; DIL16
PCF8574N: TEXAS_INSTRUMENTS_PCF8574NTEXAS_INSTRUMENTS_PCF85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; TEXAS_INSTRUMENTS_PCF8574N_0
PING1, PING2, PING3, PING4: B3B-XH-A
R1, R2, R3: 0; M2012
R4, R5, R6: 10k; R0603
RST: TS-06104
SCL: 10k; R0603
SDA: 10k; R0603
U1: ARDUINO_DUEMILANOVENOHOLESORLABELS; DUEMILANOVE_SHIELD_NOHOLES_NOLABELS
U$1, U$2: TB6612FNG; SSOP24

Connections:
+3V3: U1.3.3V
+5V: ALT1.2, ALT2.2, ALT3.2, ALT4.2, BALL1.2, BALL2.2, BALL3.2, BALL4.2, C2.+, C5.1, C7.1, C8.1, I2C.4, LINE1.2, LINE2.2, LINE3.2, LINE4.2, MCP3008.15 (VREF), MCP3008.16 (VDD), PCF8574N.16 (VCC), PING1.2, PING2.2, PING3.2, PING4.2, R4.1, R5.1, R6.1, SCL.2, SDA.2, U1.5V, U$1.19 (STBY), U$1.20 (VCC), U$2.19 (STBY), U$2.20 (VCC)
+12V: C1.+, C3.1, C4.1, U1.VIN, U$1.13 (VM2), U$1.14 (VM3), U$1.24 (VM1), U$2.13 (VM2), U$2.14 (VM3), U$2.24 (VM1)
ALT1: ALT1.1, U1.A0
ALT2: ALT2.1, U1.A1
ALT3: ALT3.1, U1.A3
ALT4: ALT4.1, U1.A2
BALL1: BALL1.1, MCP3008.5 (CH4)
BALL2: BALL2.1, MCP3008.6 (CH5)
BALL3: BALL3.1, MCP3008.7 (CH6)
BALL4: BALL4.1, MCP3008.8 (CH7)
GND: ALT1.3, ALT2.3, ALT3.3, ALT4.3, BALL1.3, BALL2.3, BALL3.3, BALL4.3, C1.-, C2.-, C3.2, C4.2, C5.2, C7.2, C8.2, I2C.1, LINE1.3, LINE2.3, LINE3.3, LINE4.3, MCP3008.9 (GND), MCP3008.14 (AGND), PCF8574N.8 (GND), PING1.3, PING2.3, PING3.3, PING4.3, R1.1, R2.1, R3.1, RST.P$3 (3), RST.P$4 (4), U1.GND@0 (GND), U1.GND@1 (GND), U1.GND@2 (GND), U$1.3 (PGND1), U$1.4 (PGND1), U$1.9 (PGND2), U$1.10 (PGND2), U$1.18 (GND), U$2.3 (PGND1), U$2.4 (PGND1), U$2.9 (PGND2), U$2.10 (PGND2), U$2.18 (GND)
LINE1: LINE1.1, MCP3008.1 (CH0)
LINE2: LINE2.1, MCP3008.2 (CH1)
LINE3: LINE3.1, MCP3008.3 (CH2)
LINE4: LINE4.1, MCP3008.4 (CH3)
MISO: MCP3008.12 (DOUT), U1.D12
MOSI: MCP3008.11 (DIN), U1.D11 (*D11)
MOTOR1CHA: M1.2, U$1.1 (A01), U$1.2 (A01)
MOTOR1CHB: M1.1, U$1.5 (A02), U$1.6 (A02)
MOTOR1INA: PCF8574N.10 (P5), U$1.21 (AIN1)
MOTOR1INB: PCF8574N.9 (P4), U$1.22 (AIN2)
MOTOR1PWM: U1.D6 (*D6), U$1.23 (PWMA)
MOTOR2CHA: M2.1, U$1.11 (B01), U$1.12 (B01)
MOTOR2CHB: M2.2, U$1.7 (B02), U$1.8 (B02)
MOTOR2INA: PCF8574N.11 (P6), U$1.17 (BIN1)
MOTOR2INB: PCF8574N.12 (P7), U$1.16 (BIN2)
MOTOR2PWM: U1.D9 (*D9), U$1.15 (PWMB)
MOTOR3CHA: M3.2, U$2.1 (A01), U$2.2 (A01)
MOTOR3CHB: M3.1, U$2.5 (A02), U$2.6 (A02)
MOTOR3INA: PCF8574N.5 (P1), U$2.21 (AIN1)
MOTOR3INB: PCF8574N.4 (P0), U$2.22 (AIN2)
MOTOR3PWM: U1.D5 (*D5), U$2.23 (PWMA)
MOTOR4CHA: M4.1, U$2.11 (B01), U$2.12 (B01)
MOTOR4CHB: M4.2, U$2.7 (B02), U$2.8 (B02)
MOTOR4INA: PCF8574N.6 (P2), U$2.17 (BIN1)
MOTOR4INB: PCF8574N.7 (P3), U$2.16 (BIN2)
MOTOR4PWM: U1.D3 (*D3), U$2.15 (PWMB)
unnamed: PCF8574N.1 (A0), R2.2, R4.2
unnamed: PCF8574N.2 (A1), R1.2, R5.2
unnamed: PCF8574N.3 (A2), R3.2, R6.2
PING1: PING1.1, U1.D2
PING2: PING2.1, U1.D4
PING3: PING3.1, U1.D7
PING4: PING4.1, U1.D8
RES2: U1.TX
RESET: RST.P$1 (1), RST.P$2 (2), U1.RES
SCK: MCP3008.13 (CLK), U1.D13
SCL: I2C.3, PCF8574N.14 (SCL), SCL.1, U1.A5
SDA: I2C.2, PCF8574N.15 (SDA), SDA.1, U1.A4
SS: MCP3008.10 (/CS), U1.D10 (*D10)

Board: 2 copper layers, 53.3 x 70.8 mm, 43 parts (13 on the bottom side), 49 nets.

Other parts of the board:
U$3: RODEP2

## Commit log

2022-06-11 #release v1
2022-06-11 # add README and releasev1zip
2022-06-11 #release Adafruit ciruit

Notices in the files:
parts and their libraries:
SparkFun-Retired: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
